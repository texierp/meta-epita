FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://swupdate.cfg \
    "
